# IAR project interrupt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21G18A Microchip ATSAMD21G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __SAMD21G18A__; F_CPU=8000000
  ICCARM.CCIncludePath2: ; config; examples; hal\include; hal\utils\include; hpl\core; hpl\dmac; hpl\eic; hpl\gclk; hpl\pm; hpl\port; hpl\sysctrl; hri; ; CMSIS\Core\Include; samd21a\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __SAMD21G18A__
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: interrupt.out
  ILINK.IlinkIcfFile: samd21a\iar\iar\samd21g18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG; __SAMD21G18A__; F_CPU=8000000
  ICCARM.CCOptLevel: 3
  group (top)
    ./: iar-project-connection.ipcf
  group src
    ./: atmel_start.c atmel_start.h atmel_start_pins.h driver_init.c driver_init.h main.c
  group src/CMSIS/Core/Include
    CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
  group src/config
    config/: hpl_dmac_config.h hpl_eic_config.h hpl_gclk_config.h hpl_pm_config.h hpl_sysctrl_config.h peripheral_clk_config.h
  group src/examples
    examples/: driver_examples.c driver_examples.h
  group src/hal/include
    hal/include/: hal_atomic.h hal_delay.h hal_ext_irq.h hal_gpio.h hal_init.h hal_io.h hal_sleep.h hpl_core.h hpl_delay.h hpl_dma.h hpl_ext_irq.h hpl_gpio.h hpl_init.h hpl_irq.h hpl_missing_features.h hpl_reset.h hpl_sleep.h
  group src/hal/src
    hal/src/: hal_atomic.c hal_delay.c hal_ext_irq.c hal_gpio.c hal_init.c hal_io.c hal_sleep.c
  group src/hal/utils/include
    hal/utils/include/: compiler.h err_codes.h events.h parts.h utils.h utils_assert.h utils_event.h utils_increment_macro.h utils_list.h utils_repeat_macro.h
  group src/hal/utils/src
    hal/utils/src/: utils_assert.c utils_event.c utils_list.c
  group src/hpl/core
    hpl/core/: hpl_core_m0plus_base.c hpl_core_port.h hpl_init.c
  group src/hpl/dmac
    hpl/dmac/: hpl_dmac.c
  group src/hpl/eic
    hpl/eic/: hpl_eic.c
  group src/hpl/gclk
    hpl/gclk/: hpl_gclk.c hpl_gclk_base.h
  group src/hpl/pm
    hpl/pm/: hpl_pm.c hpl_pm_base.h
  group src/hpl/port
    hpl/port/: hpl_gpio_base.h
  group src/hpl/sysctrl
    hpl/sysctrl/: hpl_sysctrl.c
  group src/hri
    hri/: hri_ac_d21.h hri_adc_d21.h hri_d21.h hri_dac_d21.h hri_dmac_d21.h hri_dsu_d21.h hri_eic_d21.h hri_evsys_d21.h hri_gclk_d21.h hri_hmatrixb_d21.h hri_i2s_d21.h hri_mtb_d21.h hri_nvic_d21.h hri_nvmctrl_d21.h hri_pac_d21.h hri_pm_d21.h hri_port_d21.h hri_rtc_d21.h hri_sercom_d21.h hri_sysctrl_d21.h hri_systemcontrol_d21.h hri_systick_d21.h hri_tc_d21.h hri_tcc_d21.h hri_usb_d21.h hri_wdt_d21.h
  group src/samd21a/iar
    samd21a/iar/: system_samd21.c
  group src/samd21a/iar/iar
    samd21a/iar/iar/: startup_samd21.c
  group src/samd21a/include
    samd21a/include/: component-version.h sam.h samd21.h samd21e15a.h samd21e16a.h samd21e17a.h samd21e18a.h samd21g15a.h samd21g16a.h samd21g17a.h samd21g17au.h samd21g18a.h samd21g18au.h samd21j15a.h samd21j16a.h samd21j17a.h samd21j18a.h system_samd21.h
  group src/samd21a/include/component
    samd21a/include/component/: ac.h adc.h dac.h dmac.h dsu.h eic.h evsys.h gclk.h hmatrixb.h i2s.h mtb.h nvmctrl.h pac.h pm.h port.h rtc.h sercom.h sysctrl.h tc.h tcc.h usb.h wdt.h
  group src/samd21a/include/instance
    samd21a/include/instance/: ac.h adc.h dac.h dmac.h dsu.h eic.h evsys.h gclk.h i2s.h mtb.h nvmctrl.h pac0.h pac1.h pac2.h pm.h port.h ptc.h rtc.h sbmatrix.h sercom0.h sercom1.h sercom2.h sercom3.h sercom4.h sercom5.h sysctrl.h tc3.h tc4.h tc5.h tc6.h tc7.h tcc0.h tcc1.h tcc2.h usb.h wdt.h
  group src/samd21a/include/pio
    samd21a/include/pio/: samd21e15a.h samd21e16a.h samd21e17a.h samd21e18a.h samd21g15a.h samd21g16a.h samd21g17a.h samd21g17au.h samd21g18a.h samd21g18au.h samd21j15a.h samd21j16a.h samd21j17a.h samd21j18a.h

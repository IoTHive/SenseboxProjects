<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\AP Scan Demo WINC1500.ewp</path>
    </project>
    <batchBuild />
</workspace>

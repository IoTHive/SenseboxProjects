<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ESP_XBEE_MQTT.ewp</path>
    </project>
    <batchBuild />
</workspace>
